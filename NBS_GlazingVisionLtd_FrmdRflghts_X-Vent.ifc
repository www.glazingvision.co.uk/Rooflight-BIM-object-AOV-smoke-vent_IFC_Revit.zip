Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-25T15:03:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 25 15:03:25 2017* Host: NCL-PI12* Database: C:\Users\KunduR\AppData\Local\Temp\{FE9B93FD-8819-47DD-BC5B-C110A6583878}\ifc* Database version: 5507* Database creation date: Wed Jan 25 15:03:10 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 25 15:03:24 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 25 15:03:24 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: \\NCL-S-DFS\Data\NBL\Manufacturer\G\Glazing Vision_12688\NBLA0680\Authoring\IFC\NBS_GlazingVisionLtd_FrmdRflghts_X-Vent.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcWindow: DoubleGlazed-1400x1400mm_6-20-4mm, NBS_GlazingVisionLtd_FrmdRflghts_X-Vent:DoubleGlazed-1400x1400mm_6-20-4mm:179914
In: Level 1
Type - ConstructionType: OTHER_CONSTRUCTION; OperationType: SINGLE_PANEL; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_70_65_82_56 (Uniclass2015); Material: NBS_Concept, NBS_Glass_Double
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GlazingVisionLtd_FramedRooflights_X-Vent; ManufacturerName: Glazing Vision Ltd; ManufacturerURL: www.glazingvision.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/amhchlgi; NBSDescription: Natural smoke and heat exhaust ventilators; NBSNote: 45-25-99/410 Framed rooflights; NBSOfficeMasterTag: n/a; NBSReference: 90-45-80/340; NBSTypeID: n/a; ProductInformation: www.glazingvision.co.uk/wp-content/uploads/2014/02/XV-TDS-X-Vent-Data-Sheet-v2.0.pdf; Revision: n/a; Uniclass2015Code: Pr_70_65_82_56; Uniclass2015Title: Natural smoke and heat exhaust ventilators; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: External clip on cover, Remote control, Rain sensor, Thermostat, BMS integration, Security system integration, RITEC coating,; AerodynamicFreeArea: 0; Arrangement: Glazed; CavityType: 20 mm black silicone sealed warm edge argon filled; Certification: CE Marked to BS EN 12101-2:2003, DOP No. 001GV2013-50-28; Controls: Dual scissor actuator drive, on board PCB housed within IP rated protective enclosure; DriveMechanism: Motor driven parallel linkage mechanism with encoder feedback; Guards: n/a; Initiation: Automatic device activated by a signal from the fire alarm with additional temperature redundancy at 72°; InnerPaneType: 4 mm heat soak tested soft low e toughened; IntermediatePaneType: n/a; LowAmbientTemperatureClassification: T -15°C; MaterialsFinish: Principal components polyester powder coated; MaterialsFrame: Aluminium; MaterialsGlazing: 30 mm insulating glass unit; MaterialsLouvers: n/a; MaximumArea: 2.6 m²; MaximumSize: 1900 mm width, 1400 mm span; MinimumSize: 1400 mm width, 1400 mm span; OpeningAngle: 104° AOV operation, 0-45° ventilation range; OpeningTime: ≤60 seconds; OpeningType: Hinged for vent; OuterPaneType: 6 mm heat soak tested toughened; PitchAngleRange: 3-5°; PowerSupply: Extenal 28 V, 28 A, 750 W switch mode power supply; back up batteries included in case of mains failure; ReliabilityClassification: Re 50; ResistanceToHeatClassification: B 300°C; Seals: Combination of three silicone bubble seals; Security: Mechanism cannot be disconnected from lid whilst closed, mechanisms prevent the lid from being forced open; SnowLoadClassification: SL 125 Pa; ThermalBreak: yes; WindLoadClassification: WL 1500 Pa
Type - Pset_WindowCommon - AcousticRating: n/a; FireRating: Class A1; GlazingAreaFraction: 0; Infiltration: 0; IsExternal: yes; Reference: n/a; SecurityRating: n/a; SmokeStop: no; ThermalTransmittance: 0
Type - Pset_DoorWindowGlazingType - BeamRadiationTransmittance: 0; FillGas: Argon; GlassColor: Clear; GlassLayers: 2; GlassThickness1: 6 mm; GlassThickness2: 4 mm; GlassThickness3: 0 mm; IsCoated: yes; IsLaminated: no; IsTempered: yes; IsWired: no; Reflectivity: 0; SolarHeatGainTransmittance: 0; ThermalTransmittanceSummer: 0; ThermalTransmittanceWinter: 0; Translucency: 0
Type - Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 750; HasProtectiveEarth: no; InsulationStandardClass: n/a; IP_Code: n/a; NominalCurrent: 28; NominalFrequencyRange: n/a; NominalVoltage: 28 V; NumberOfPoles: 0; PhaseAngle: 0; PhaseReference: n/a; UsageCurrent: 28
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_65_82_56 : Natural smoke and heat exhaust ventilators; CodePerformance: To BS EN 12101-2:2003; Color: RAL 7015 Grey outer, RAL 9010 inner, clear glass; Constituents: Aluminium frame, double IGU; Description: Glazed heat and smoke ventilator for flat roof applications; DurationUnit: year; ExpectedLife: n/a; Features: CE marked, automatically opens to 140°, thermally broken framework, battery back up as standard; Finish: n/a; Grade: n/a; Manufacturer: sales@glazingvision.co.uk; Material: Aluminium, glass; ModelNumber: 405; ModelReference: GV X-Vent Double Glazed AOV; Name: NaturalSmokeandHeatExhaustVentilators_X-VentAOV_DoubleGlazed_GlazingVisionLtd; NominalHeight: 0 mm; NominalLength: 1400 mm; NominalWidth: 1400 mm; ReplacementCost: n/a; Shape: Rectangular; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer's warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2 (installed by others) or 10 years (installed by Glazing Vision); WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: customerservices@glazingvision.co.uk
OverallHeight: 498.471 mm; OverallWidth: 1400 mm
NBS_Data - ComponentNumber: n/a; WindowNumber: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
